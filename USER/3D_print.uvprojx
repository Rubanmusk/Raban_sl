# Keil uVision project 3D_print.uvprojx, settings and files
target 3Dprint (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 3D-Printer +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\LCD;..\HARDWARE\SPI;..\MALLOC;..\HARDWARE\FLASH;..\FATFS\src;..\FATFS\exfuns;..\TEXT;..\Thermistor;..\Marlin;..\Step_motor;..\APP;..\HARDWARE\ADC;..\Gui;..\HARDWARE\TOUCH;..\HARDWARE\WATCHDOG;..\HARDWARE\SD_SDIO
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c system_stm32f10x.c stm32f10x_it.c
  group APP
    ../APP/: Abnormal_Handling.c gcodeplayer.c
  group HARDWARE
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/TOUCH/: ctiic.c touch.c
    ../HARDWARE/WATCHDOG/: watchdog.c
    ../HARDWARE/SD_SDIO/: sdio_sdcard.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/SPI/: spi.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_sdio.c stm32f10x_dma.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
    ../FATFS/src/: diskio.c ff.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group Thermister
    ../Thermistor/: temperature.c
  group Marlin
    ../Marlin/: ConfigurationStore.c Marlin.c motion_control.c planner.c
  group Step_motor
    ../Step_motor/: stepper.c
  group GUI
    ../Gui/: button.c filelistbox.c graph.c gui.c icon_code.c label_code.c lcdmenu.c listbox.c progressbar.c scrollbar.c lcd_240_320.c
